Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-15T14:57:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 15 14:57:53 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{4A1276CC-A420-4F4B-A6FC-7F32C6518C7C}\ifc * Database version: 5507 * Database creation date: Thu Mar 15 14:57:46 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 15 14:57:46 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 15 14:57:46 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Height=10.65m(34'-11")_Reach=3.08m(10'-1"), 1001150411_T12E PLUS:Height=10.65m(34'-11")_Reach=3.08m(10'-1"):402842
In: Level 1
Type - Material: JLG_Plastic_Yellow, JLG_Plastic_Green, JLG_Plastic_Blue, JLG_Plastic_Red, JLG_Paint_Black, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_Orange, JLG_Rubber_CYAN, JLG_Plastic_Dark Grey, JLG_Steel, JLG_Paint_Beige, JLG_Paint_Silver Grey, JLG_Plastic_Ligh tGrey, JLG_Rubber_Black
Type - Constraints - AE: 3360 mm; AEa: 60 deg; Height: 6817 mm; Reach: 56
Type - Data - Control system: 12V DC; Drive speed - lowered: 5.5km/h (3.42 mph); Electrical (pump) motor: 3kw 48V DC; Gradeability: 25%; Horizontal Outreach: 5.55 m (18 ft 3 in); Hydraulic system: 21.8 L (5.76 gal); Jib – Overall Length: 4.14m(13 ft 7 in); Machine weight 2WS (CE): 4,900 kg (10,803 lbs); Max Ground Bearing Pressure (CE): 14.0 kg/cm2 (199.12 psi); Platform Capacity (CE): 200 kg (441 lbs); Platform Height: 10.65 m (34 ft 11 in); Platform Rotator: 2x60 degree; Platform Size: 0.70 m x 1.05 m (2 ft 4 inx3 ft 5 in); Swing: 345° (non cont inuous); Turning Radius Inside: 0.75m (2 ft 6 in); Turning Radius Outside: 2.60m (8 ft 6.5 in); Tyres (non-marking solid): 457mmdia x 178mm width; Up and Over Height: 6.95 m (22 ft 9 in)
Type - Dimensions - AEa1: 240 deg; E: 1120 mm; PHa: -60 deg; PHa1: 120 deg
Type - General - Platform Rotation (Option): 2x60 degree; Platform Side Entry: 0.70 m x 1.05 m; Tilt Alarm/Indicator Light: 3 degree tilt alarm and indicator light
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Height=10.65m(34'-11")_Reach=3.08m(10'-1")
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001150411_Toucan 12E PLUS; NBSDescription: Mast boom lifts; NBSNote: n/a; NBSObjectName: JLG_Toucan 12E PLUS Mast boom lifts; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001150411_T12E PLUS; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: Toucan 12E PLUS; ModelReference: JLG_Mast boom lifts; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com; WarrantyStartDate: Please Record On Commissioning
Pset_BuildingElementProxyCommon - Reference: Height=10.65m(34'-11")_Reach=3.08m(10'-1")
Pset_ManufacturerTypeInformation - ModelReference: JLG_Mast boom lifts; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 171.922 m2; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa: 180 deg; Swing_A: 0 deg; Swing_Angle: 0 deg; Turning Radius: no; Volume: 1.21321 m3; Working Area: no
Identity Data - Mark: 13
Other - Family: 1001150411_T12E PLUS: Height=10.65m(34'-11")_Reach=3.08m(10'-1"); Family and Type: 1001150411_T12E PLUS: Height=10.65m(34'-11")_Reach=3.08m(10'-1"); Type: 1001150411_T12E PLUS: Height=10.65m(34'-11")_Reach=3.08m(10'-1"); Type Id: 1001150411_T12E PLUS: Height=10.65m(34'-11")_Reach=3.08m(10'-1")
Phasing - Phase Created: Phase 1
